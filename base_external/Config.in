## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_project_base_PATH/package/monitor/Config.in"
source "$BR2_EXTERNAL_project_base_PATH/package/monitorws/Config.in"
```
